# Keil uVision project Project.uvprojx, settings and files
target FWLib (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: SPD1177,ARM_MATH_CM4, __FPU_PRESENT=1,__TARGET_FPU_VFP, __CC_ARM
  c include: ..\..\..\..\Libraries\CMSIS\core;..\..\..\..\Libraries\CMSIS\device;..\..\..\..\Libraries\drivers\inc;..\..\..\..\Libraries\drivers\inc\reg;..\..\..\..\Utilities
  memory RVCT4: ROM 0xffffffff size 0xffffffff
  memory RVCT9: RAM 0xffffffff size 0xffffffff
  scatter file: .\Project.sct
  group User
    ../: isr.c main.c arm_cortexM4lf_math.lib
  group Periph_Driver
    ../../../../Libraries/drivers/src/: adc.c clock.c comp.c dma.c ecap.c epwr.c gpio.c spd1177_hv.c hwlib.c pga.c phcomp.c power.c pwm.c spi.c system.c timer.c uart.c wdt.c pin.c can.c crc.c i2c.c
  group CMSIS
    ../../../../Libraries/CMSIS/device/startup/arm/: startup_spc1169.s
    ../../../../Libraries/CMSIS/device/: system_spc1169.c
  group Utilities
    ../../../../Utilities/: delay.c retarget.c
