# IAR project Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: SPD1177
  ICCARM.CCIncludePath2: ..; ..\..\..\..\..\Libraries\CMSIS\core; ..\..\..\..\..\Libraries\CMSIS\device; ..\..\..\..\..\Libraries\drivers\inc\reg; ..\..\..\..\..\Libraries\drivers\inc; ..\..\..\..\..\Utilities; ..\src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: spc1169.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../../../../../Libraries/CMSIS/device/startup/iar/: startup_spc1169.s
    ../../../../../Libraries/CMSIS/device/: system_spc1169.c
  group IAP
    ../src/: iap.c
  group Periph_Driver
    ../../../../../Libraries/drivers/src/: adc.c can.c clock.c comp.c crc.c dma.c ecap.c engr.c epwr.c gpio.c hwlib.c i2c.c pga.c phcomp.c pin.c power.c pwm.c spd1177_hv.c spi.c system.c timer.c uart.c wdt.c
  group User
    ../: isr.c main.c
  group Utilities
    ../../../../../Utilities/: delay.c retarget.c
