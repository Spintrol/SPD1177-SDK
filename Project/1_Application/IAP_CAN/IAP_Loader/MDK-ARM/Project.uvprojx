# Keil uVision project Project.uvprojx, settings and files
target FWLib (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: SPD1179
  c include: ..\..\..\..\..\Libraries\CMSIS\core;..\..\..\..\..\Libraries\CMSIS\device;..\..\..\..\..\Libraries\drivers\inc;..\..\..\..\..\Libraries\drivers\inc\reg;..\..\..\..\..\Utilities;..\src;..\
  memory RVCT4: ROM 0x10000000 size 0xf000
  memory RVCT9: RAM 0x1fffc000 size 0x3000
  group User
    ../: main.c isr.c
  group Periph_Driver
    ../../../../../Libraries/drivers/src/: adc.c clock.c comp.c dma.c ecap.c gpio.c hwlib.c pga.c phcomp.c power.c pwm.c spi.c system.c timer.c uart.c wdt.c pin.c can.c crc.c i2c.c spd1179_hv.c epwr.c
  group CMSIS
    ../../../../../Libraries/CMSIS/device/startup/arm/: startup_spc1169.s
    ../../../../../Libraries/CMSIS/device/: system_spc1169.c
  group Utilities
    ../../../../../Utilities/: delay.c retarget.c
  group IAP
    ../src/: iap.c
