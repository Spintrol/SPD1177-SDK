# Keil uVision project Single.uvprojx, settings and files
target FWLib (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: SPD1177
  c include: ..\..\..\..\Libraries\CMSIS\core;..\..\..\..\Libraries\CMSIS\device;..\..\..\..\Libraries\drivers\inc;..\..\..\..\Libraries\drivers\inc\reg;..\..\..\..\Utilities;..\..\..\..\Libraries\lin_stack\inc;..\;..\single
  memory RVCT4: ROM 0x10000000 size 0xf000
  memory RVCT9: RAM 0x1fffc000 size 0x3000
  group User
    ../: main.c isr.c
    ../single/: lin_cfg.c
  group Periph_Driver
    ../../../../Libraries/drivers/src/: adc.c clock.c comp.c dma.c ecap.c gpio.c pin.c hwlib.c pga.c phcomp.c power.c pwm.c system.c timer.c uart.c wdt.c epwr.c spd1177_hv.c
  group CMSIS
    ../../../../Libraries/CMSIS/device/startup/arm/: startup_spc1169.s
    ../../../../Libraries/CMSIS/device/: system_spc1169.c
  group Utilities
    ../../../../Utilities/: delay.c retarget.c
  group lin_stack
    ../../../../Libraries/lin_stack/src/: lin.c lin_common_api.c lin_common_proto.c lin_commontl_api.c lin_commontl_proto.c lin_diagnostic_service.c lin_lin21_api.c lin_lin21_proto.c lin_lin21tl_api.c lin_lld_uart.c
